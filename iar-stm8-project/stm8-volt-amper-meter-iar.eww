<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\stm8-volt-amper-meter-iar.ewp</path>
    </project>
    <batchBuild />
</workspace>
