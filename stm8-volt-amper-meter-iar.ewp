# IAR project stm8-volt-amper-meter-iar.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 2
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.PreInclude: config.h
  ICCSTM8.CCIncludePath2: E:\p\!electronics\!stm8\stm8-bare-min\stm8s\include\stm8-bare-min; E:\p\!electronics\!mcu\include; E:\p\!cpp\include
  ICCSTM8.IccLang: 2
  OBJCOPY.OOCOutputFile: heater pid controller.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: heater pid controller.out
  group src
    src/: main.cpp
  group stm8s-bare-min
    ../../../!stm8/stm8-bare-min/stm8s/include/stm8-bare-min/: delay.c delay.h eeprom.c eeprom.h i2c.h stm8s.h uart.c uart.h
